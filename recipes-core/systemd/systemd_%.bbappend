PACKAGECONFIG:remove = "networkd resolved nss-resolve"

DEPENDS += "glib-2.0"